# Autodesk Inventor part: CR-01
## iProperties
Created: 2005-12
Part Number: CR-01
Document SubType Name: Modeling
Designer: YellowCake
Author: YellowCake
## Feature names
1. 派生ボディ1 [Tagging]

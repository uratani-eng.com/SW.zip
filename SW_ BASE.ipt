# Autodesk Inventor part: SW_ BASE
## iProperties
Created: 2005-12
Part Number: SW_ BASE
Document SubType Name: Modeling
Designer: YellowCake
Author: YellowCake
## Feature names
1. 押し出し1 [Extrusion]
